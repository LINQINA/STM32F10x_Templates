# Keil uVision project STM32F10x-Templates.uvprojx, settings and files
target APP (6160000::V6.16::ARMCLANG)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32F10x-Templates +hex
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ..\Firmware\CMSIS\Device\ST\STM32F1xx\Include;..\Firmware\STM32F1xx_HAL_Driver\Inc;..\Firmware\CMSIS\Include;..\APP;..\BSP;..\User
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group BSP
    ../BSP/: DevicesLed.c
  group Firmware
    ../Firmware/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_hal_dma.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c
  group System
    ../Firmware/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
    ../Firmware/CMSIS/Device/ST/STM32F1xx/Source/Templates/arm/: startup_stm32f103xe.s
  group User
    ../User/: main.c stm32f1xx_it.c
