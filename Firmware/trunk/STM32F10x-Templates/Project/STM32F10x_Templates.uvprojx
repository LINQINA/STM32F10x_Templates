# Keil uVision project STM32F10x_Templates.uvprojx, settings and files
target APP (6160000::V6.16::ARMCLANG)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32F10x_Templates +hex
  AfterMake: $K\ARM\ARMCLANG\bin\fromelf.exe --bin --output=Bin\@L.bin !L
  AfterMake: copy hex file.bat
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103xE
  c misc: -Wno-invalid-source-encoding
  c include: ..\Firmware\CMSIS\Device\ST\STM32F1xx\Include;..\Firmware\STM32F1xx_HAL_Driver\Inc;..\Firmware\CMSIS\Include;..\APP;..\BSP;..\User;..\Middlewares\FreeRTOS\Kernel\include;..\Middlewares\FreeRTOS\Kernel\portable\GCC\ARM_CM3;..\Modules\Log;..\Modules\Modbus;..\Modules\Bootloader;..\Modules\OTA
  library: MicroLIB
  memory RVCT4: ROM 0x801a000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group FreeRTOS
    ../Middlewares/FreeRTOS/Kernel/include/: FreeRTOSConfig.h
    ../Middlewares/FreeRTOS/Kernel/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../Middlewares/FreeRTOS/Kernel/portable/MemMang/: heap_4.c
    ../Middlewares/FreeRTOS/Kernel/portable/GCC/ARM_CM3/: port.c
  group Firmware
    ../Firmware/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_i2c.c stm32f1xx_hal_spi.c stm32f1xx_hal_can.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_pwr.c
  group System
    ../Firmware/CMSIS/Device/ST/STM32F1xx/Source/Templates/arm/: startup_stm32f103xe.s
  group BSP
    ../BSP/: DevicesADC.c DevicesBeep.c DevicesLed.c DevicesKey.c DevicesRTC.c DevicesTime.c DevicesTimer.c DevicesSoftTimer.c DevicesDelay.c DevicesUart.c DevicesRS485.c DevicesQueue.c DevicesModbus.c DevicesCRC.c DevicesIIC.c DevicesAT24C02.c DevicesCAN.c DevicesSPI.c DevicesSPIFlash.c DevicesFlash.c DevicesWatchDog.c
  group Modules
    ../Modules/Log/: DriverLogPrintf.c
    ../Modules/Modbus/: DriverModbus.c
    ../Modules/Bootloader/: DriverBootloader.c
  group Modules_OTA
    ../Modules/OTA/: DriverOTA.c DriverUpgradePD.c
  group APP
    ../APP/: taskSystem.c taskMonitor.c taskSensor.c taskControl.c taskSoftTimer.c taskKey.c taskMessageSlave.c taskOTA.c
  group User
    ../User/: main.c stm32f1xx_it.c userSystem.c version.c userMath.c
    ../Firmware/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
